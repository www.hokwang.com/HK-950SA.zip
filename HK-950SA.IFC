Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-950SA.IFC
Time: 2022-01-04T06:40:14
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 950SA壓條
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 950SA外殼_2L
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 950SA導光柱
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: C529-1鎖頭_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: M5釐帽_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: RSD背板
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 給皂機半牙螺絲B (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 給皂機矽膠軟管
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 透視窗
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
